# IAR project STM8S_MBUS_SLAVER.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: C:\AAA_Workspace\IAR_CodeDir\STM8S_MBUS_SLAVER\Drive; C:\AAA_Workspace\IAR_CodeDir\STM8S_MBUS_SLAVER\User; C:\AAA_Workspace\IAR_CodeDir\STM8S_MBUS_SLAVER\Libraries\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_MBUS_SLAVER.srec
  ILINK.IlinkOutputFile: STM8S_MBUS_SLAVER.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group DRIVE
    ../Drive/: timer.c timer.h uart.c uart.h watermeter.c watermeter.h
  group FWLIB
    ../Libraries/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group USER
    ../User/: app_scheduler.c app_scheduler.h debug.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h test.c test.h
